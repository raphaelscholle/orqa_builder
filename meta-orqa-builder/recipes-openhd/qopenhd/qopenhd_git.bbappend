SRC_URI = "gitsm://github.com/OpenHD/QOpenHD.git;protocol=https;branch=dev-release"
SRCREV = "${AUTOREV}"
PV = "dev-release+git${SRCPV}"

